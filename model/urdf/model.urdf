Commit message: nav stack set up

File: model/urdf/model.urdf (robot description, URDF)
Before this commit: robot model, 6 links, 5 joints
Joints:
- joint lidarjoint: origin xyz=-0.29589 -0.15066 0.011838 rpy=1.5708 0 -0.025697 -> xyz=-0.29589 -0.15066 0.011838 rpy=0 3.14 0
